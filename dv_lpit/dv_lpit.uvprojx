# Keil uVision project dv_lpit.uvprojx, settings and files
target dv_lpit (6140000::V6.14::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dv_lpit
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group source
    ./Source/: lpit.c main.c nvic.c port_gpio.c scg.c systick.c
  group include
    ./Include/: common.h gpio.h lpit.h main.h nvic.h pcc.h port.h port_gpio.h scg.h systick.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.0
